	AREA RESET, DATA, READONLY
		DCD 0X20002000
		DCD MAIN
	AREA DATA1, DATA, READONLY
MATRAN1
	DCD 1,2,3,4
	DCD 2,5,2,-2
	DCD 2,-3,4,1
	DCD -7,2,-2,9
KT1 DCD 16; KICH THUOC MA TRAN
	AREA DATA2, DATA, READONLY
MATRAN2
	DCD 1,2,3,4
	DCD 2,5,2,-2
	DCD 2,-3,4,1
	DCD -7,2,-2,9
KT2 DCD 16; KICH THUOC MA TRAN
	AREA KQ, DATA, READWRITE
KETQUA DCD 0
	AREA HUU, CODE, READONLY
	ENTRY
MAIN
	LDR R0, =KETQUA; DIA CHI MA TRAN KQ
	LDR R3, KT1; SO PHAN TU MA TRAN 1
	LDR R4, KT2; SO PHAN TU MA TRAN 2
	CMP R3, R4
	BNE STOP; SO PHAN TU KHAC NHAU <=> MA TRAN K CUNG CAP, K THE CONG
	LDR R1, =MATRAN1
	LDR R2, =MATRAN2
	MOV R7, #0; HIEU
LOOP
	LDR R5, [R1], #4; LAY PHAN TU RA TU MATRAN, CAP NHAT DIA CHI MATRAN DEN VI TRI TIEP THEO
	LDR R6, [R2], #4
	SUB R7, R5, R6; TINH HIEU 
	STR R7, [R0], #4; LUU LAI VAO MA TRAN KET QUA
	SUB R3, #1; GIAM BIEN DIEM SO PHAN TU
	CMP R3, #0
	BEQ STOP
	B LOOP
STOP
	END