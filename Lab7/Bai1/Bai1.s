;; TINH TICH VO HUONG 2 VECTOR 
	AREA RESET, DATA, READONLY
		DCD 0X20002000
		DCD MAIN
	AREA DATA, DATA, READONLY
VECTOR1 DCD 4; DO DAI VECTOR
	DCB 1,2,3,4
VECTOR2 DCD 4
	DCB 2,3,5,6
	AREA KETQUA, DATA, READWRITE
KQ DCD 0
	AREA HUU, CODE, READONLY
	ENTRY
MAIN
	LDR R0, =VECTOR1
	LDR R1, =VECTOR2
	LDR R2, [R0], #4
	LDR R3, [R1], #4
	CMP R2, R3
	BNE STOP; DO DAI 2 VECTOR KHAC NHAU
	MOV R7, #0; KQ CUOI
	MOV R6, #0; TG
LOOP
	LDRB R4,[R0], #1
	LDRB R5,[R1], #1
	MUL R6, R4, R5
	ADD R7, R6
	SUB R2, #1
	SUB R3, #1
	CMP R2, #0
	BEQ STOP
	B LOOP
STOP
	LDR R2,=KQ
	STR R7, [R2]
	END