	AREA RESET, DATA, READONLY
		DCD 0X20001000
		DCD MAIN
MATRIX DCD 0,4,5,5
	   DCD 6,4,8,7
	   DCD 4,5022,6,8
	   DCD 5,6,7,4
SOHANG DCD 4
SOCOT DCD 4

	AREA MYCODE, CODE, READONLY
	ENTRY

MAIN
	MOV R0, #0
	LDR R1, =MATRIX
	LDR R2, [R1]
	
	LDR R3, SOHANG
	LDR R4, SOCOT

	MOV R5, R4 ;; BIEN CHAY
	SUB R5, #1 
	
	MOV R6, #4 ;; SO BYTE NHAY
	MUL R5, R5, R6
	
	ADD R1, R5 ;; CHAY DEN PHAN TU CUOI HANG 1
	
LOOP
	CMP R3, #0
	BEQ STOP
	
	LDR R2, [R1]
	ADD R1, R5
	
	AND R7, R2, #1
	CMP R7, #0
	BEQ CHAN
	
	SUB R3, #1
	B LOOP

CHAN
	ADD R0, #1
	SUB R3, #1
	B LOOP
	
STOP B STOP

	END