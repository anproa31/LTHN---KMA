	AREA RESET, DATA, READONLY
		DCD 0X20001000
		DCD MAIN
MATRIX DCD 2,4,5,5
	   DCD 6,1,8,7
	   DCD 4,5,61,8
	   DCD 5,6,7,1109
SOHANG DCD 4
SOCOT DCD 4

	AREA MYCODE, CODE, READONLY
	ENTRY

MAIN
	MOV R0, #0
	LDR R1, =MATRIX
	LDR R2, [R1]
	
	LDR R3, SOHANG
	LDR R4, SOCOT

	MOV R5, R4 ;; BIEN CHAY
	ADD R5, #1 
	
	MOV R6, #4 ;; SO BYTE NHAY
	MUL R5, R5, R6
	
LOOP
	CMP R3, #0
	BEQ STOP
	
	LDR R2, [R1]
	ADD R1, R5
	
	CMP R2, #1
	BLE NOTPRIME
	
	MOV R7, R2
	SUB R7, #1
	
PRIMECHECK
	CMP R7, #1
	BEQ ISPRIME
	
	UDIV R8, R2, R7
	MUL R8, R7
	
	CMP R8, R2
	BEQ NOTPRIME
	
	SUB R7, #1
	B PRIMECHECK

ISPRIME 
	ADD R0, #1
	
	SUB R3, #1
	B LOOP

NOTPRIME
	SUB R3, #1
	B LOOP
	
STOP B STOP

	END