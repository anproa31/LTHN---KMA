	AREA RESET, DATA, READONLY
		DCD 0X20001000
		DCD MAIN
M1 DCB 1,2
   DCB 3,4
   DCB 5,8
   
M2 DCB 5,6,10
   DCB 7,8,9
   
COL1 EQU 2
COL2 EQU 3
ROW1 EQU 3
ROW2 EQU 2
	
	AREA KETQUA, DATA, READWRITE
KQ DCB 0
	
	AREA MYCODE, CODE, READONLY
	ENTRY
	
MAIN
	MOV R0, #COL1
	MOV R1, #ROW2
	
	CMP R0,R1
	BNE STOP
	
	LDR R0, =M1
	LDR R1, =M2
	LDR R2, =KQ
	
	MOV R4, #0 ;; BIEN CHAY I
	
LOOP1
	CMP R4, #ROW1 ;; I < SOHANG 1
	BEQ STOP
	
	MOV R5, #0 ;; BIEN CHAY J
	
LOOP2
	CMP R5, #COL2 ;; J < SOCOT 2
	BEQ NEXT1
	
	MOV R6, #0 ;; BIEN CHAY K
	MOV R12, #0 ;; LUU TAM THOI KET QUA
	
LOOP3
	CMP R6, #COL1 ;; K < SOCOT 1
	BEQ NEXT2
	
	MOV R10, #ROW1
	MUL R10, R4
	ADD R7, R10, R6 ;; I * SOCOT1 + K
	
	LDRB R7, [R0, R7]
	
	MOV R10, #ROW2
	MUL R10, R6
	ADD R8, R10, R5 ;; K * SOCOT2 + J
	
	LDRB R8, [R1, R8]
	
	MUL R9, R7, R8
	ADD R12, R9
	
	ADD R6, #1
	
	B LOOP3
	
NEXT1
	ADD R4, #1
	B LOOP1

NEXT2
	ADD R5, #1
	STRB R12, [R2], #1
	B LOOP2


STOP B STOP

	END
	
	
	