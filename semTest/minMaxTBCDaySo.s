	AREA RESET, DATA, READONLY
		DCD 0X20001000
		DCD MAIN
CHUOI DCD 5,4,56,23,2,3,23
PT DCD 7

	AREA MYCODE, CODE, READONLY
	ENTRY

MAIN
	MOV R0, #0 ;; MIN
	MOV R1, #0 ;; MAX
	MOV R2, #0 ;; PT LON HON TBC

	LDR R3, =CHUOI
	LDR R4, [R3]
	LDR R5, PT
	
	MOV R6, #0 ;; TBC
	
	MOV R0, R4
	MOV R1, R4

LOOP
	CMP R5, #0
	BEQ TBC
	
	LDR R4, [R3], #4
	
	ADD R6, R4
	
	CMP R0, R4
	BGT MIN
	
	CMP R1, R4
	BLT MAX
	
	SUB R5, #1
	B LOOP
	
MIN
	MOV R0, R4
	
	SUB R5, #1
	B LOOP

MAX
	MOV R1, R4
	
	SUB R5, #1
	B LOOP

TBC
	LDR R5, PT
	UDIV R6, R5
	
DUYETLAI
	LDR R3, =CHUOI
	LDR R4, [R3]

LOOP1
	CMP R5, #0
	BEQ STOP
	
	LDR R4, [R3], #4
	
	CMP R4, R6
	BLT LONHON
	
	SUB R5, #1
	B LOOP1
	
LONHON
	ADD R2, #1
	SUB R5, #1
	B LOOP1
	
STOP B STOP

	END