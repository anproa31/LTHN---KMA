	AREA RESET, DATA, READONLY
		DCD 0X20001000
		DCD MAIN
MATRIX DCD 0,4,5
	   DCD 6,4,500
	   DCD 4,5,6
PT DCD 9

	AREA MYCODE, CODE, READONLY
	ENTRY

MAIN
	MOV R0, #0
	LDR R1, =MATRIX
	LDR R2, [R1]
	
	LDR R3, PT
	MOV R4, #5 ;; SO CHIA

LOOP
	CMP R3, #0
	BEQ STOP

	LDR R2, [R1], #4
	
	SDIV R5, R2, R4
	MUL R5, R4
	
	CMP R5, R2
	BEQ CHIAHET
	
	SUB R3, #1
	B LOOP

CHIAHET
	ADD R0, #1
	
	SUB R3, #1
	B LOOP

STOP B STOP

	END