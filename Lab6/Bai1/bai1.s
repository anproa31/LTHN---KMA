;Vi?t cсc chuong trьnh so sсnh 2 xтu (cрi d?t theo d? dрi)
	AREA RESET,DATA,READONLY
		DCD 0x20001000
		DCD start
	ALIGN
CHUOIA 	DCD 5
		DCB "MINH"
CHUOIB 	DCD 5
		DCB "MINH"

	AREA KETQUA,DATA,READWRITE
KQ DCD 0	
	AREA MYCODE,CODE,READONLY
	ENTRY
start
;=====================
	LDR R0, =CHUOIA 
	LDR R1, =CHUOIB 
	LDR R2, =KQ 
	LDR R3, [R0], #4; DO DAI CUA CHUOI SO
	LDR R4, [R1], #4 
	CMP R3, R4 
	BNE KHACNHAU	; R3 != R4 THI DO DAI KHAC NHAU
	CMP R3, #0; DO DAI BANG 0 THI K CO PHAN TU NAO
	BEQ TUONGTU ; DO DAI GIONG NHAU,KI TU GIONG NHAU
LOOP 
	LDRB R5, [R0], #1 ;LAY TU DAU TIEN
	LDRB R6, [R1], #1 ; LAY TU DAU TIEN
	CMP R5, R6	;KIEM TRA 
	BNE KHACNHAU ; != LA KHACNHAU
	SUBS R3, R3, #1; GIAM SO PHAN TU DI
	SUBS R4, R4, #1;GIAM SO PHAN TU DI
	CMP R3, #0; KIEM TRA DEN KHI NAO MA R3 = 0 THI THOI VI HET PHAN TU
	BEQ TUONGTU	;DO DAI GIONG NHAU,KI TU GIONG NHAU
	B LOOP	; DO DAI BANG NHAU KI TU GIONG NHAU
TUONGTU
	MOV R7,#0x11111111	;NEU GIONG NHAU EM DE  #0x11111111 CHO DE NHIN
	STR R7, [R2]	;R7 VAO DIA CHI R2
	B STOP
KHACNHAU
	MOV R7,#0x00000000
	STR R7, [R2]
STOP
	SWI &11
;=====================
	END