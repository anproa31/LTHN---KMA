; CHUAN HOA XAU
	AREA RESET, DATA, READONLY
		DCD 0X20002000
		DCD start
chuoi DCB "   BUI QUOC AN       ",0

	AREA KETQUA, DATA, READWRITE
KQ DCB 0

	AREA MYCODE, CODE, READONLY
	ENTRY
start
	LDR R0, =chuoi
	LDR R1, =KQ
LOOP1	; XOA KI TU CACH O DAU CHUONG TRIFNH
	LDRB R2, [R0], #1	;LAY KI TU DAU TIEN CUA CHUOI
	CMP R2, #32; SO SANH VOI DAU CACH DAU CAC CO DANG LA &#32
	BEQ LOOP1	;NEU BANG THI QUAY LAI KIEM TRA XEM KI TU TIEP THEO XEM PHAI DAU CACH HAY K
	CMP R2, #0	;KIEM TRA XEM R2 CO PHAI KI TU KET THUC K NEU LA KET THUC THI DUNG LAI
	BEQ STOP	;
	STRB R2, [R1], #1	;CON NEU K PHAI KHOANG TRANG HAY 0  THI LUU VAO KQ 0xR1 = 0X
	B NEXT
NEXT
	LDRB R2, [R0], #1	; LAY KI TU TIEP THEO
	STRB R2, [R1], #1; LUU NO VAO R1 0xR1 = 0X OX
	CMP R2, #32; KIEM TRA XEM PHAI DAU CACH K
	BEQ LOOP1	;NEU LA DAU CACH THI QUAY LAI LOOP1
	B NEXT
STOP
	SUB R1, #1	; TRU DI PHAN TU CUOI CUNG LA DAU CACH
	MOV R2, #0	;SAU DO ADD KI TU KET THUC VAO CUOI 
	STRB R2, [R1]
EXIT B EXIT
	END