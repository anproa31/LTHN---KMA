
	AREA RESET,DATA,READONLY
		DCD 0x20001000
		DCD MAIN
	ALIGN
MA DCB 0,1,1,0,1,0,1,0,1
SPT DCB 9
	
	AREA KETQUA,DATA,READWRITE
KQ DCB 0	
	AREA MYCODE,CODE,READONLY
	ENTRY
MAIN
;==========================================
	LDR R0,=MA
	MOV R2,#0
	MOV R3,#0
	LDRB R4,SPT
	LDR R5,=KQ
	ADD R5,#10 //add memory address to point to the next byte
	
LOOP
	LDRB R1,[R0],#1
	CMP R4,#0
	BEQ NEXT
	CMP R1,#1
	ADDEQ R2,#1
	ADDNE R3,#1
	SUB R4,#1
	B LOOP
NEXT
	CMP R2,R3
	BGT	LE
	BLT	CHAN
	BEQ THOAT

LE
	MOV R0,#1
	STRB R0,[R5]
	B THOAT

CHAN
	MOV R0,#0
	STRB R0,[R5]
	B THOAT

THOAT
	SWI &11
;==========================================
	END
