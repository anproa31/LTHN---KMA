; dem so phan tu la so nguyen to nho hon N
	AREA RESET, DATA, READONLY
		DCD 0X20001000
		DCD MAIN
N DCD 11,7,3,4,6
SPT DCD 5
	AREA mycode, CODE, READONLY
	ENTRY
MAIN
	MOV R0, #0; TONG
	LDR R1, =N	; R1 = 100
	LDR R7,SPT
	BL CT
	B STOP ;THOAT
CT PROC 
LOOP
	LDR R2,[R1],#4
	CMP R7,#0 ;kim tra R2,R1 NEU > THI DUNG LAI
	BEQ STOP
	CMP R2, #1 ;KIEM TRA R2 = 1 THI TANG LEN 1 VI Nс K PHAI LA SNT
	BEQ NEXT	;CHAY DEN NOI DE R2 TANG LEN 1
	CMP R2, #3	;KIEM TRA R2 VA 3 
	BLE SNT	;NEU R2 <= 3 THI SNT + 1 = R0 + 1
	MOV R3, R2; CрN >  THI SAO CHEP R3 = R2 DE TINH
	MOV R4, #2; R4 =2 DE SU DUNG CHO PHEP CHIA 2
KIEMTRA2	
	UDIV R5, R3, R4; R5=R3/R4
	MUL R6, R5, R4; 
	CMP R6, R2; SO SANH R6 VOI R2 KIEM TRA NEU = NHAU THI LA CHIA DC 
	BEQ NEXT	; NEU = THI KP LA SNT
	MOV R4, #3	; KO = THI GAN R4 = 3 DE KT VOI 3 
KIEMTRA3
	UDIV R5, R3, R4; R5=R3/R4
	MUL R6, R5, R4; 
	CMP R6, R2; SO SANH R6 VOI R2 KIEM TRA NEU = NHAU THI LA CHIA DC
	BEQ NEXT ; NEU = THI KP LA SNT
	CMP R2, #5	;KIEM TRA VOI 5 VI 5 CUNG LA SNT
	BEQ SNT	; R2 = 5 THI LA SNT
	MOV R4, #5 ; KO = THI GAN R4 = 5 DE KT VOI 5
KIEMTRA5
	UDIV R5, R3, R4; R5=R3/R4
	MUL R6, R5, R4; 
	CMP R6, R2; SO SANH VOI SO BAN DAU
	BEQ NEXT
	CMP R2, #7;KIEM TRA VOI 7 VI 7 CUNG LA SNT
	BEQ SNT	;R2 = 7 THI LA SNT
	MOV R4, #7; KO = THI GAN R4 = 7 DE KT VOI 7 
KIEMTRA7
	UDIV R5, R3, R4; R5=R3/R4
	MUL R6, R5, R4; 
	CMP R6, R2; SO SANH VOI SO BAN DAU
	BEQ NEXT
	B SNT
SNT
	ADD R0,R2
	B NEXT
NEXT
	SUB R7,#1; GIAM
	B LOOP
	ENDP
STOP
	SWI &11
	END