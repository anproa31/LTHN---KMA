; 16 SANG 8 THI CHUYEN 16 VE 10 TRUOC, ROI 10 SANG 8
	AREA RESET, DATA, READONLY
		DCD 0X20002000
		DCD MAIN
CS16 DCB &0F, &0A, &07, &0
SPT16 DCB 4
	AREA DATA1, DATA, READWRITE
KQ DCB 0
	AREA MYCODE, CODE, READONLY
	ENTRY
MAIN
	LDRB R0, SPT16 ;R0 =4
	SUB R0, #1 ;TRU R0 DI 1
	LDR R1, =CS16
	MOV R2, #0; KET QUA O HE 10
	MOV R3, #16; DUNG DE NHAN
CHUYENSANG10
	CMP R0, #0
	BEQ TG ;BANG 0 CHUYEN SANG 8
	LDRB R4, [R1], #1 ; GаN GIа TRI R1 CHO R4 R?I TANG R1 LEN 1
	MOV R5, #1; GAN R5 = 1
NHAN
	MUL R4, R3 ;NHAN R4 = R4 X R3 GIA TRI CUA R1 X R3
	ADD R5, #1 ;TANG R5 LEN 1
	CMP R5, R0 ; KIEM TRA R5 VOI R0
	BLE NHAN	;NEU <= THI NHAN TIEP 
	ADD R2, R4	; ADD R2 = R2 + R4
	SUB R0, #1 	;XONG TRU R0 DI 1
	B CHUYENSANG10 ;XONG TIEP  CHUYENSANG10
TG
	LDRB R4, [R1]
	ADD R2, R4;
	LDR R1, =KQ
	MOV R3, #8; DUNG DE CHIA
CHUYENSANG8
	UDIV R4, R2, R3
	MUL R5, R4, R3
	SUB R2, R5
	STRB R2, [R1], #1
	CMP R4, #0
	MOV R2, R4
	BGT CHUYENSANG8
	SWI &11
STOP
	END