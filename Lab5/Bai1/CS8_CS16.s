	AREA RESET, DATA, READONLY
		DCD 0X20002000
		DCD MAIN
DULIEU DCB 7,4,2,0
SPT DCB 4
	AREA DATA1, DATA, READWRITE
RESULT DCB 0
	AREA DATA2, DATA, READWRITE
RESULT2 DCB 0
	AREA HUU, CODE, READONLY
	ENTRY
MAIN
	LDRB R0, SPT ; R0 = 4
	SUB R0, #1 ; R0 = R0 -1
	LDR R1, =DULIEU ;DIA CHI DT CUA DULIEU
	LDR R2, =RESULT ;DIA CHI CUA RESULT
	ADD R2,#10
	MOV R3, #8	;
	MOV R4, #0; KQ O HE 10
LOOP1
	CMP R0, #0 
	BEQ TG 
	LDRB R5, [R1], #1 ; 
	MOV R6, #1; I
NHAN
	MUL R5, R3 ;NHAN
	ADD R6, #1 ;TRU DI 1
	CMP R6, R0 ; KIEM TRA
	BLE NHAN	; NHO HON NHAN TIEP
	ADD R4, R5	; ADD LAY HE CO Sс 1O
	SUB R0, #1
	B LOOP1
TG; LAY PHAN TU CUOI CUNG RA
	LDRB R5, [R1]
	ADD R4, R5
	STR R4, [R2]
	LDR R3, =RESULT2
	MOV R4, 0XF; MASK
LOOP2;
	LDRB R5, [R2], #1
	CMP R5, #0
	BEQ STOP
	MOV R6, R5, LSR #0X4
	MOV R6, R6, LSL #0X8
	AND R5, R5, R4
	ADD R6, R5
	STRH R6, [R3], #2
	B LOOP2
STOP
	END