;; MA HOA DICH VONG
	AREA RESET, DATA, READONLY
		DCD 0X20000000
		DCD MAIN
CHUOI DCB "THIeNZ MenHz",0
KEY DCB 3
	AREA DATA1, DATA, READWRITE
KETQUA DCB 0;
	AREA HUU, CODE, READONLY
	ENTRY
MAIN
	LDRB R0, KEY
	LDR R1, =CHUOI
	LDR R3, =KETQUA
LOOP
	LDRB R2, [R1], #1
	CMP R2, #0; CO PHAI NULL HAY K
	BEQ STOP
	CMP R2, #32; CO PHAI DAU CACH HAY KHONG
	BEQ TIEP
	CMP R2, #90; SO SANH VOI Z
	BLE KITUHOA
KITUTHUONG
	ADD R2, R0
	CMP R2, #122; LON HON z
	BGT DICHVONG
	BLE TIEP
KITUHOA
	ADD R2, R0
	CMP R2, #90; LON HON Z
	BGT DICHVONG
	BLE TIEP
DICHVONG
	SUB R2, #26
TIEP
	STRB R2, [R3], #1
	B LOOP
STOP
	END
	