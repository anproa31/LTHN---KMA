	AREA RESET, DATA, READONLY
		DCD 0X20002000
		DCD MAIN
CHUOI DCB "THIEN MENH",0
	AREA DATA1, DATA, READONLY
HOANVI DCB 10,9,8,7,6,5,4,2,3,1,0,11,19,18,17,16,14,15,13,12,20,22,24,25,23,21
	AREA DATA2, DATA, READWRITE
RESULT DCB 0
	AREA HUU, CODE, READONLY
	ENTRY
MAIN
	LDR R0, =CHUOI
	LDR R1, =HOANVI
	LDR R2, =RESULT
LOOP
	LDRB R3, [R0], #1
	CMP R3, #0
	BEQ STOP
	CMP R3, #32
	MOV R4, R3
	BEQ SAVE1
	SUB R3, #65
	LDRB R4, [R1,R3]
	ADD R4, #65
	CMP R4, #90
	BLE SAVE1
	SUB R4, #26
SAVE1
	STRB R4, [R2], #1
	B LOOP
STOP
	END